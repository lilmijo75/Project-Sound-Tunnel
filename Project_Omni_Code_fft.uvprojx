# Keil uVision project Project_Omni_Code_fft.uvprojx, settings and files
target Target_1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_Omni_Code
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\Tivaware-master\Tivaware-master\driverlib;.\Tivaware-master\Tivaware-master\inc
  asm include: ..\..\..\Downloads\Tivaware-master\Tivaware-master\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ./: ws2812_pwm.c adc_driver.c fft.c
  group inc
    ./: ws2812_pwm.h adc_driver.h fft.h
software components: CMSIS Driver:GPIO:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Device:Startup 1.0.1
